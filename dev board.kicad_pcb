# Repository 0xmanidev/dev-board

File README.md:

# dev-board
this is a project made for hackclub blueprint event I made this project to get more into pcb design and electronics this is a stepping stone for me because I always been a software kind of guy

I used rp2040 from raspberry pi as micro controller I taken inspiration from pico and improved it based on my learning like pwm etc..

I chose rp2040 because it has great support with circuit python and that's the language I am familiar with.

I journalled everything in hack club https://blueprint.hackclub.com/projects/13798

made with ❤️ and with the help of hack club community

## KiCad design dev board.kicad_pcb

Board: 2 copper layers, 21.0 x 51.0 mm, 55 parts (7 on the bottom side), 60 nets.

Parts:
C1, C5: 100n; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C2, C3: 18p; C_0402_1005Metric
C4: 2.2u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C7: 10n C0G; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8, C9, C11, C13, C14, C15, C16, C17, C18: 100n; C_0402_1005Metric
C10, C12: 1u; C_0402_1005Metric
D1: B5819W; D_SOD-123
D2, D3: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_Palconn_UTC16-G
J2: SWD; Pico_4pin
J3: LEFT; Pico_20pin
J4: RIGHT; Pico_20pin
JP1: EEPROM_WP; SolderJumper-3_P2.0mm_Open_TrianglePad1.0x1.5mm
JP2: VREF; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
R1: 1k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R2: DNP; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R3, R4: 5.1k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R5, R10, R11, R12, R13: 1k; R_0402_1005Metric
R6: 470mOhm; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R7: 150; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8, R9: 27; R_0402_1005Metric
SW1: BOOTSEL; SW_SPST_B3U-1000P
SW2: RES; SW_SPST_B3U-1000P
TP1: BOOTSEL; TestPoint_Pad_1.5x1.5mm
TP2: VREG; TestPoint_Pad_1.5x1.5mm
TP3: GP25; TestPoint_Pad_1.5x1.5mm
TP4: GND; TestPoint_Pad_1.5x1.5mm
TP5: D+; TestPoint_Pad_1.5x1.5mm
TP6: GP24; TestPoint_Pad_1.5x1.5mm
TP7: D-; TestPoint_Pad_1.5x1.5mm
U1: FM24CL16B; SOIC-8_3.9x4.9mm_P1.27mm
U2: W25Q16JVUXIQ; IC_W25Q16JVUXIQ_TR
U3: AMS1117-3.3; SOT-223-3_TabPin2
U4: LM4040DBZ-3; SOT-23
U5: RP2040; RP2040-QFN-56
Y1: ECS-120-12-36-AGN-TR3; Crystal_SMD_2520-4Pin_2.5x2.0mm

Connections:
+1V1: C8.1, C9.1, C10.1, TP2.1, U5.23 (DVDD), U5.45 (VREG_VOUT), U5.50 (DVDD)
+3V3: C1.1, C5.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, J4.16, JP1.1 (A), R2.1, R6.2, R7.2, R10.1, R11.1, U1.8 (VDD), U2.8 (VCC), U3.2 (VO), U5.1 (IOVDD), U5.10 (IOVDD), U5.22 (IOVDD), U5.33 (IOVDD), U5.42 (IOVDD), U5.44 (VREG_IN), U5.48 (USB_VDD), U5.49 (IOVDD)
+5V: C4.1, D1.1 (K), J4.19, U3.3 (VI)
/3V0_VREF: JP2.2 (B), R7.1, U4.1 (K)
/ADC_VREF: C7.1, J4.15, JP2.1 (A), U5.43 (ADC_AVDD)
/D+: J1.A6 (D+), J1.B6 (D+), R8.1, TP5.1
/D-: J1.A7 (D-), J1.B7 (D-), R9.1, TP7.1
/DN: R9.2, U5.46 (USB_DM)
/DP: R8.2, U5.47 (USB_DP)
/EEPROM_SCL: D3.2 (A), R11.2, TP3.1, U1.6 (SCL), U5.37 (GPIO25)
/EEPROM_SDA: R10.2, TP6.1, U1.5 (SDA), U5.36 (GPIO24)
/EEPROM_WP: JP1.2 (C), U1.7 (WP)
/GPIO0: J3.1, U5.2 (GPIO0)
/GPIO1: J3.2, U5.3 (GPIO1)
/GPIO2: J3.4, U5.4 (GPIO2)
/GPIO3: J3.5, U5.5 (GPIO3)
/GPIO4: J3.6, U5.6 (GPIO4)
/GPIO5: J3.7, U5.7 (GPIO5)
/GPIO6: J3.9, U5.8 (GPIO6)
/GPIO7: J3.10, U5.9 (GPIO7)
/GPIO8: J3.11, U5.11 (GPIO8)
/GPIO9: J3.12, U5.12 (GPIO9)
/GPIO10: J3.14, U5.13 (GPIO10)
/GPIO11: J3.15, U5.14 (GPIO11)
/GPIO12: J3.16, U5.15 (GPIO12)
/GPIO13: J3.17, U5.16 (GPIO13)
/GPIO14: J3.19, U5.17 (GPIO14)
/GPIO15: J3.20, U5.18 (GPIO15)
/GPIO16: J4.1, U5.27 (GPIO16)
/GPIO17: J4.2, U5.28 (GPIO17)
/GPIO18: J4.4, U5.29 (GPIO18)
/GPIO19: J4.5, U5.30 (GPIO19)
/GPIO20: J4.6, U5.31 (GPIO20)
/GPIO21: J4.7, U5.32 (GPIO21)
/GPIO22: J4.9, U5.34 (GPIO22)
/GPIO23: D2.2 (A), U5.35 (GPIO23)
/GPIO26_ADC0: J4.11, U5.38 (GPIO26_ADC0)
/GPIO27_ADC1: J4.12, U5.39 (GPIO27_ADC1)
/GPIO28_ADC2: J4.14, U5.40 (GPIO28_ADC2)
/GPIO29_ADC3: J4.17, U5.41 (GPIO29_ADC3)
/QSPI_SCLK: U2.6 (CLK), U5.52 (QSPI_SCLK)
/QSPI_SD0: U2.5 (DI(IO0)), U5.53 (QSPI_SD0)
/QSPI_SD1: U2.2 (DO(IO1)), U5.55 (QSPI_SD1)
/QSPI_SD2: U2.3 (IO2), U5.54 (QSPI_SD2)
/QSPI_SD3: U2.7 (IO3), U5.51 (QSPI_SD3)
/QSPI_SS: R1.1, R2.2, U2.1 (~CS), U5.56 (QSPI_SS)
/RUN: J2.4, J4.10, SW2.1, U5.26 (RUN)
/SWCLK: J2.1, U5.24 (SWCLK)
/SWD: J2.3, U5.25 (SWD)
/XIN: C2.1, U5.20 (XIN), Y1.3
/XOUT: R5.1, U5.21 (XOUT)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.2, J3.3, J3.8, J3.13, J3.18, J4.3, J4.8, J4.13, J4.18, JP1.3 (B), R3.2, R4.2, R12.2, R13.2, SW1.1, SW2.2, TP4.1, U1.4 (VSS), U2.4 (GND), U3.1 (GND), U4.2 (A), U5.19 (TESTEN), U5.57 (GND), Y1.2, Y1.4
unnamed: C3.1, R5.2, Y1.1
unnamed: C6.1, R6.1
unnamed: D2.1 (K), R12.1
unnamed: D3.1 (K), R13.1
unnamed: J1.A5 (CC1), R4.1
unnamed: J1.B5 (CC2), R3.1
unnamed: R1.2, SW1.2, TP1.1
VBUS: D1.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J4.20

## Commit log

2026-03-25 file upload
2026-03-25 renaming
2026-03-25 Enhance README with project details and inspiration
    Expanded project description and added details about the microcontroller and inspiration.
2026-03-25 photo upload
